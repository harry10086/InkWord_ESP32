# Repository harry10086/InkWord_ESP32

File README.md:

# InkWordESP32 (桌面水墨单词卡与日历)

**InkWordESP32** 是一款基于 **ESP32-S3** 与 **4.2 寸红黑白三色电子墨水屏** 打造的低功耗多功能桌面单词卡学习与时钟日历设备。

它兼具 **英语单词记忆**、**公农历时钟日历**、**双语每日名言**、**全盘 Web 文件管理器** 与 **极低功耗待机** 体系，采用纸质般无闪烁护眼显示，适合放置在办公桌、书桌上陪伴日常学习与工作。

> [!IMPORTANT]
> 红白黑三色电子标签屏虽然便宜（闲鱼 10 元），但是**刷新时间大约 15 秒！刷新时间大约 15 秒！刷新时间大约 15 秒！**

---

## 📸 屏幕布局与视觉分区

4.2 寸三色墨水屏（400 × 300 像素）精心规划了四大功能区域，红黑搭配，主次分明：

```
+--------------------------------------------------------------------------+
| [状态栏] 词库名: CET4 | 模式: 随机 | WiFi: 已连接 | 电量: [⚡ 85%] (3.92V)   |
+------------------------------------+-------------------------------------+
| [左侧: 时钟与日历区]               | [右侧: 单词背诵区]                  |
| 14:35 (2026-10-09 星期五)          | abandon                             |
| 农历: 八月廿九                     | /əˈbændən/ [IPA标准点阵音标]        |
|                                    | vt. 放弃，遗弃；离弃                |
| 日 一 二 三 四 五 六               | n. 放任，放纵                       |
|        1  2  3  4 [5]              |                                     |
|  6  7  8  9 10 11 12               | [页码: 1/2]                         |
+------------------------------------+-------------------------------------+
| [底部: 每日名言区] (红黑双色)                                            |
| The secret of getting ahead is getting started.                          |
| 千里之行，始于足下。                                                     |
+--------------------------------------------------------------------------+
```

---

## 🛠️ 硬件方案与电气规格

### 1. 核心硬件组件
* **主控芯片**：乐鑫 **ESP32-S3**。
* **显示屏**：**4.2 寸红黑白三色电子墨水屏**（型号：`SE2417FS051`，主控 IC：`UC8176`，分辨率 400 × 300，SPI 通信接口）。
* **存储扩展**：**MicroSD (TF) 卡槽**，采用 **4-bit 高速 SDMMC 硬件总线**，大幅提升词库检索与大文件传输效率。
* **电源与供电**：
  * 单节 18650 锂电池供电（标称 3.7V / 满电 4.2V）；
  * **ADC 电池采样**：GPIO 3，通过 1/4 精密电阻分压实时测量电量；
  * **充电检测**：GPIO 1，通过硬件电平感知充电状态（低电平充电中，高电平充满/未插线）；
  * **硬件级保护**：当电压低于 3.15V（剩余电量 ≤ 5%）时，屏幕自动显示低电警告并进入 Deep Sleep，仅保留充电线插入唤醒。
* **物理按键**：精简为 3 颗按键，具有独立硬件滤波与长短按状态机。

### 2. 硬件架构
硬件使用 KiCad 设计（我认为这是目前个人及中小型公司最适合最好用的 EDA 软件），设计架构如下：

**PCB 图：**

**IO 分配：**

| 模块分类 | 信号功能 | GPIO 引脚 | 说明与特性 |
| :--- | :--- | :--- | :--- |
| **电子墨水屏** | `PIN_CS` | **IO 9** | 屏幕片选信号 (低电平有效) |
| | `PIN_SCLK` | **IO 10** | SPI 时钟信号 (硬件 HSPI) |
| | `PIN_SDI` | **IO 11** | SPI 数据输入 MOSI |
| | `PIN_D_C` | **IO 17** | 数据 / 命令控制引脚 |
| | `PIN_RST` | **IO 18** | 屏幕硬件复位引脚 |
| | `PIN_BUSY` | **IO 8** | 屏幕忙碌状态检测 |
| **MicroSD (4-bit)** | `PIN_SD_DAT0` | **IO 5** | SDMMC 数据线 0 |
| | `PIN_SD_DAT1` | **IO 4** | SDMMC 数据线 1 |
| | `PIN_SD_DAT2` | **IO 16** | SDMMC 数据线 2 |
| | `PIN_SD_DAT3` | **IO 15** | SDMMC 数据线 3 / CS |
| | `PIN_SD_CLK` | **IO 6** | SDMMC 时钟线 |
| | `PIN_SD_CMD` | **IO 7** | SDMMC 命令线 |
| **电源与交互按键** | `PIN_BAT_ADC` | **IO 3** | 电池电压检测 (1/4 硬件分压) |
| | `PIN_CHRG` | **IO 1** | 充电状态引脚 (低电平充电，支持 RTC 唤醒) |
| | `PIN_KEY1` | **IO 39** | 按键 1：Wi-Fi 开关 / 强制 AP 热点配网 |
| | `PIN_KEY2` | **IO 40** | 按键 2：上一个单词 / 长按切换顺序/随机模式 |
| | `PIN_KEY3` | **IO 41** | 按键 3：下一个单词(释义翻页) / 长按切换词库 |

**按键操作指南：**

| 按键 | 短按操作 (单击) | 长按操作 (按住 ≥ 1.5 秒) |
| :--- | :--- | :--- |
| **KEY 1** (GPIO 39) | **开 / 关 Wi-Fi**：开启时自动连接已知网络并进行对时与名言同步；再次短按关闭。 | **强制 AP 配网**：秒级唤起 `InkWord-Setup` 独立配网热点，手机直连 192.168.4.1。 |
| **KEY 2** (GPIO 40) | **上一个单词**：回退至上一个单词，进度记忆至 RTC 与 NVS。 | **切换播放模式**：在【顺序】与【随机】模式间切换。 |
| **KEY 3** (GPIO 41) | **下一个单词 / 释义翻页**：若词条解释多于一页先翻页，翻完后切换至下一词。 | **切换词库**：轮换 TF 卡 `/dict/` 目录下的多本词典（CET4, CET6, IELTS 等）。 |

> [!TIP]
> 顺便说一句，我之所以用这些元件并不是必须，而是我手上刚好有这些元件，可根据自己的情况处理，硬件结构都是，我提供的均是源文件，可自行修改。

### 3. 结构设计

外壳结构采用 SolidWorks 进行设计，使用拓竹 3D 打印机打印，最好使用不同材料支撑，不然不太好拆除。

---

## 🌟 核心软件特性

### 1. 单词背诵引擎
* **标准化 JSON 词库支持**：词库放置于 TF 卡 `/dict/` 目录，支持自定义单词、音标及释义。
* **原生 8×16 IPA 国际音标点阵字模库**：内置 44 个标准国际音标（含 `ə, ɪ, æ, ʌ, ɒ, ɔ, ʊ, ɜ, ʃ, ʒ, θ, ð, ŋ, ˈ, ˌ, ː` 等），彻底解决墨水屏常见英汉音标乱码与粘连问题。
* **智能长释义分页**：自动计算中文词条换行与高度，超出单屏自动分页（通过 KEY3 顺序翻阅）。
* **自动切词定时器**：支持 1~60 分钟自动切换下一词（可通过 Web 随时调整）。

### 2. 高精度时钟与日历体系
  1. **芯片 RTC Slow Clock 硬件计数器**：在轻度休眠（Light Sleep）与异常复位期间始终保持计时，时间精度永不中断；
  2. **NTP + HTTP 双重授时**：开机与每日定时联网自动同步阿里云 NTP；若局域网拦截 UDP 123 端口，自动回退利用 HTTP 服务器响应头 `Date` 兜底授时。
  3. **公农历算法与月视图**：屏幕左侧实时计算并显示公历日期、星期、农历月份与初几/廿几（含闰月计算），并以红框在当前月份日历矩阵中精准高亮今日。

### 3. 每日金山双语名言 (联网更新 + 离线轮播)
* **联网自动更新与归档**：每天早晨 7:00 自动开启 Wi-Fi，请求金山词霸每日名言接口，英文大字加粗，中文优雅小字，自适应排版折行，并自动追加归档至 TF 卡 `/quote/quotes.json`。
* **离线自动轮播**：若设备处于无网环境或断网，早晨 7:00 会自动触发离线轮换机制，从 TF 卡历史名言库中随机抽取未显示的名言并刷新墨水屏，保证每天名言按时更换。

### 4. Multi-AP 多网络记忆与自适应智能重连
* **多凭据记忆**：支持记忆多达 **8 个常用 Wi-Fi 网络**，采用 MRU（最近使用置顶）机制。
* **快速扫描智能匹配**：每日唤醒对时或短按 KEY1 开网时，首先执行 250ms/信道的快速扫描，自动识别周边信号最强的已知网络秒级连接。
* **回退保护**：若遇到隐藏 SSID，自动按优先级遍历尝试连接。

### 5. 现代化 Web 控制中心与全盘文件管理器
连接设备 IP 地址（或 AP 模式下的 `http://192.168.4.1`），即可进入 web 控制台：
* **实时设备状态看板**：查看当前 IP、信号强度、电池电压、系统运行时间、当前词库等。
* **个性化系统设置**：调节单词自动切换间隔（1~60分钟）、Wi-Fi 无操作自动休眠倒计时（1~60分钟）、开启/关闭深夜静默模式。
* **全功能 SD 卡文件管理器**：
  * 支持文件的上传、下载、删除、重命名、新建文件夹；
  * 支持目录穿梭，方便随时导入新词库或管理历史名言。
* **可视化 Wi-Fi 配置**：支持周边 Wi-Fi 扫描列表与一键连接。
* **OTA 无线固件升级**：支持网页端直接上传编译好的 `.bin` 固件一键在线刷机。

### 6. 深度低功耗电源管理
* **Light Sleep 浅度睡眠**：非充电、无按键操作且关闭 Wi-Fi 时，CPU 自动进入浅度睡眠，按键即点即应，电流大幅下降。
* **深夜静默模式 (23:00 ~ 07:00)**：自动停止单词切换与夜间物理刷屏，延长墨水屏寿命并极度节能。
* **无操作自动断网**：Wi-Fi 开启后若超过设定时间（默认 6 分钟）无数据交互，自动关闭射频硬件并将 CPU 降频至 80MHz。

---

## 💻 固件开发与编译指南

### 1. 开发环境要求
* **IDE**：推荐使用 [Arduino IDE 2.x](https://www.arduino.cc/en/software)。
* **ESP32 支持包**：`esp32 by Espressif Systems`（建议版本 **2.0.14** 或 **3.0.x**）。
* **板卡型号选择**：`ESP32S3 Dev Module`。

### 2. 核心依赖三方库
在 Arduino IDE 的 **项目 -> 加载库 -> 管理库** 中搜索并安装以下依赖：

| 依赖库名称 | 推荐版本 | 用途 |
| :--- | :--- | :--- |
| **GxEPD2** | `>= 1.5.x` | 4.2 寸电子墨水屏核心驱动 (`GxEPD2_420c`) |
| **Adafruit GFX Library** | `>= 1.11.x` | 基础图形渲染框架 |
| **U8g2_for_Adafruit_GFX** | 最新版 | 中文字库与点阵字体渲染引擎 |
| **ArduinoJson** | `>= 7.x` | 词库、名言与 Web API 数据的高效 JSON 序列化/反序列化 |

### 3. Arduino IDE 编译选项配置 (Tools 菜单)

| 选项名称 (Menu) | 推荐参数值 (Value) | 说明 |
| :--- | :--- | :--- |
| **Board** | `ESP32S3 Dev Module` | 主板架构 |
| **USB CDC On Boot** | `Enabled` | 启用原生 USB 虚拟串口调试输出 |
| **CPU Frequency** | `240MHz (WiFi)` | 最高性能运行 |
| **Flash Mode** | `QIO 80MHz` | 保证 Flash 读取性能 |
| **Flash Size** | `16MB ` 或 `8MB` | 依据具体模组选配 |
| **Partition Scheme** | `Minimal SPIFFS (1.9MB APP with OTA/190KB SPIFFS)` | 必须给 APP 分区留足空间 |
| **PSRAM** | `OPI PSRAM` 或 `Disabled` (视硬件模组配置) | 若模组带 PSRAM 则开启 |
| **Upload Mode** | `UART0 / Hardware CDC` | 固件烧录接口 |

---

## 📁 TF 卡目录与数据规范

为使设备开机正常读取词库与名言，TF 卡应格式化为 **FAT32** 格式，并建议建立如下目录：

```
MicroSD (根目录)
├── dict/                    # 单词词库文件夹
│   ├── CET4.json            # 四级词汇
│   ├── CET6.json            # 六级词汇
│   └── TOEFL.json           # 托福词汇
├── quote/                   # 每日名言文件夹
│   └── quotes.json          # 历史名言本地归档库 (单文件追加模式)
└── schedule.json            # 日程备忘清单 (可选，Web端可视化维护)
```

### 词库 JSON 格式规范 (`/dict/*.json`)
可在网站免费下载：[https://typewords.cc/dict](https://typewords.cc/dict)
```json
[
  {
    "word": "abandon",
    "phonetic": "/əˈbændən/",
    "trans": [
      "vt. 放弃，遗弃；离弃",
      "n. 放任，放纵"
    ]
  },
  {
    "word": "ability",
    "phonetic": "/əˈbɪləti/",
    "trans": [
      "n. 能力，本领；才能"
    ]
  }
]
```

---

## 📜 版本更新历史 (Changelog)

### v1.1.3
* 🚀 **多网络记忆系统 (Multi-AP)**：支持存储多达 8 个常用 Wi-Fi，新增周边热点快速扫描匹配与信号强度自适应重连，解决多环境不自动回连的问题。
* 📖 **每日名言双轨切换机制**：增加离线名言自动轮换，每日早晨 7 点即便无网也能从 TF 卡历史名言中轮换并刷新屏幕；抽取算法改用 `esp_random()` 并增加防连抽去重。
* 🔒 **SD 卡总线安全加固**：增加 `sdMutex` 互斥保护锁，彻底消除主循环写入名言与后台墨水屏任务读词库的并发冲突。

### v1.1.2
* 🌙 **深夜静默模式**：支持 23:00 ~ 07:00 停止物理刷屏并提供 Web 开关。
* 📶 **独立 AP 配网热点**：支持短按/长按 KEY1 秒级唤起 `InkWord-Setup` (192.168.4.1) 免 App 网页可视化配网。
* 🎲 **全库遍历洗牌算法**：乱序序列持久化到 SD 卡，当前背词进度通过 RTC 硬件级记忆。
* 📅 **农历算法修复**：修复农历计算与闰月交替显示问题。

### v1.1.1 & v1.1.0
* 🔋 **电源与显示优化**：优化低电休眠界面与 ADC 电池采样算法，解决低功耗漏电；
* ⚡ **开机自动对时**：修复电量耗尽充电后首次启动未成功网络对时的问题。

---

## 📄 开源许可证
本项目基于 [GNU General Public License v3.0 (GPLv3)](LICENSE) 协议开源。

## KiCad design HW/InkWordESP32_MB_V1.1/InkWordESP32_MB_V1.1.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via

Connections:
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1); also elsewhere on the board

Notes on the sheet:
POWER
ESP32-S3

Parts:
C1, C2, C6, C7, C11: 100nF ±10% 50V; C0603; Manufacturer Part CC0603KRX7R9BB104; LCSC C14663
C3, C10, C13: 10uF 10V; C0603; Manufacturer Part CL10A106KP8NNNC; LCSC C19702
C4, C5, C8, C9, C12, C14, C15, C16, C17: 1uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC C15849
C18: 4.7uF; C0603; Manufacturer Part CL10A475KA8NQNC; LCSC C69335
C19: 10uF 50V; C0805; Manufacturer Part CL21A106KBYQNNE; LCSC C2932476
CN1: ZX-XH2.54-2PWZ; CONN-TH_2P-P2.50_ZX-XH2.54-2PWZ; LCSC Part C7429641
D1, D2, D3: RCLAMP0521T-ES; DFN1006-2L; Manufacturer Part RCLAMP0521T-ES; LCSC C5180263
D4, D5, D6: B5819WS; Manufacturer Part B5819WS; LCSC C7420331
F1, F2: BSMD0603L-100; Fuse_0603_1608Metric; Manufacturer Part BSMD0603L-100; LCSC C2757929
FB1: 600Ω@100MHz; L0603; Manufacturer Part GZ1608D601TF; LCSC C1002
FPC1: AFC04-S24FCA-00; Manufacturer Part AFC04-S24FCA-00; LCSC C883632
L1: 100uH; LQH3NPZ101MMEL; Manufacturer Part LQH3NPZ101MMEL; LCSC C703088
Q1: SI1308EDL-T1-GE3; Manufacturer Part SI1308EDL-T1-GE3; LCSC C469327
R1: 1kΩ; R0603; Manufacturer Part 0603WAF1001T5E; LCSC C21190
R2, R3: 5.1kΩ ±1%; R0603; Manufacturer Part 0603WAF5101T5E; LCSC C23186
R4, R6, R9: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC C25804
R5: 3kΩ ±1%; R0603; Manufacturer Part 0603WAF3001T5E; LCSC C4211
R7: 0R; R0603; LCSC Part C100044
R8: 0R; R0603; LCSC Part C100044; not fitted
R10: 3Ω; R0603; Manufacturer Part RCA033RFLF; LCSC C22356394
S1: SS12D10G6-WJ; Manufacturer Part SS12D10G6-WJ; LCSC C7431059
U1: XB6366D; Manufacturer Part XB6366D; LCSC C2760016
U2: TP4055; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; Manufacturer Part TP4055; LCSC C28441
U3: XC6220B331MR-G; Manufacturer Part XC6220B331MR-G; LCSC C86534
USB1: TYPE-C16PIN; Manufacturer Part TYPE-C16PIN; LCSC C393939

Connections:
/power/BS: FPC1.17, R7.2, R8.1
/power/EPD_3V3: C7.1, C19.2, FB1.2, FPC1.9, FPC1.10, L1.1, R8.2
/power/GDR: FPC1.23, Q1.1 (G), R9.1
/power/PREVGH: C14.2, D6.2 (K), FPC1.4
/power/PREVGL: C16.2, D5.1 (A), FPC1.2
/power/RESE: FPC1.22, Q1.2 (S), R10.1
BUSY: FPC1.16; also elsewhere on the board
CHRG: R4.2, U2.1 (CHRG); also elsewhere on the board
CS: FPC1.13; also elsewhere on the board
D_C: FPC1.14; also elsewhere on the board
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C19.1, D1.2, D2.2, D3.2, D4.2 (K), FPC1.8, FPC1.25, FPC1.26, R2.1, R3.1, R5.2, R7.1, R9.2, R10.2, U1.4 (VM), U1.5 (VM), U1.6 (VM), U2.2 (GND), U3.2 (VSS), USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND); also elsewhere on the board
unnamed: C4.2, FPC1.21
unnamed: C5.2, FPC1.20
unnamed: C8.2, FPC1.7
unnamed: C9.2, FPC1.6
unnamed: C12.2, FPC1.5
unnamed: C15.2, FPC1.3
unnamed: C17.2, FPC1.1
unnamed: C18.2, D4.1 (A), D5.2 (K)
unnamed: C18.1, D6.1 (A), L1.2, Q1.3 (D)
unnamed: F2.1, S1.1
unnamed: C1.1, CN1.2, U1.2 (GND), U1.3 (GND), U1.7 (EP)
unnamed: C1.2, R1.2, U1.1 (VDD)
unnamed: R5.1, U2.5 (PROG)
unnamed: R6.2, U3.3 (CE)
unnamed: R2.2, USB1.A5 (CC1)
unnamed: R3.2, USB1.B5 (CC2)
RST: FPC1.15; also elsewhere on the board
SCLK: FPC1.12; also elsewhere on the board
SDI: FPC1.11; also elsewhere on the board
USB_5V: C2.2, C3.2, F1.1, S1.3, U2.4 (VCC)
USB_DN: D2.1, USB1.A7 (DN1), USB1.B7 (DN2); also elsewhere on the board
USB_DP: D1.1, USB1.A6 (DP1), USB1.B6 (DP2); also elsewhere on the board
VBUS: D3.1, F1.2, USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
VDD3V3: C10.2, C11.2, FB1.1, R4.1, U3.5 (VOUT); also elsewhere on the board
VIN: C13.2, R6.1, S1.2, U3.1 (VIN); also elsewhere on the board
Vbat: C6.2, CN1.1, F2.2, R1.1, U2.3 (BAT)

Notes on the sheet:
排线下接

Parts:
C20, C22, C25, C26, C27, C35, C37: 100nF ±10% 50V; C0603; Manufacturer Part CC0603KRX7R9BB104; LCSC C14663
C21, C23: 10uF 10V; C0603; Manufacturer Part CL10A106KP8NNNC; LCSC C19702
C24: 100nF 50V; C0603; Manufacturer Part CC0603KRX7R9BB104; LCSC C14663
CN2: ZX-XH2.54-3PZZ; CONN-TH_3P-P2.54_2501S-3P; LCSC Part C7429633
D7, D8, D9, D10, D11, D12, D13, D14, D15, D17: RCLAMP0521P-N; Manufacturer Part RCLAMP0521P-N; LCSC C316043
K1, K2, K3: TS-1009B-05026; Manufacturer Part TS-1009B-05026; LCSC C455252
R11: 3MΩ ±1%; R0603; Manufacturer Part 0603WAF3004T5E; LCSC C23156
R12: 1MΩ ±1%; R0603; LCSC Part C22935
R13, R14, R15, R16, R17, R18, R22, R26, R29, R30, R34, R38: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC C25804
R19, R20, R21, R23, R24, R25, R36, R37: 10Ω; R0603; Manufacturer Part RC0603FR-0710RL; LCSC C109318
R27: 33Ω; R0603; Manufacturer Part 0603WAF330JT5E; LCSC C23140
SW1, SW2: GT-L5.2-W5.2-H015; SW-SMD_4P-L5.2-W5.2-P3.70-LS6.4; LCSC Part C29780122
TF1: TF-CARD_H1_8; Manufacturer Part TF-CARD H1.8; LCSC C7529389
U4: ESP32-S3-WROOM-1_N16R8; Manufacturer Part ESP32-S3-WROOM-1-N16R8; LCSC C2913202

Connections:
/ESP32-S3-MINI/SD_DAT0: D11.2, R17.1, R24.1, TF1.7 (DAT0)
/ESP32-S3-MINI/SD_DAT1: D12.2, R18.1, R25.1, TF1.8 (DAT1)
/ESP32-S3-MINI/SD_DAT2: D7.2, R13.1, R19.1, TF1.1 (DAT2)
/ESP32-S3-MINI/SD_DAT3: D8.2, R14.1, R20.1, TF1.2 (CD/DAT3)
BAT_ADC: C37.2, R11.2, R12.1, U4.15 (IO3)
BUSY: U4.12 (IO8); also elsewhere on the board
CHRG: U4.39 (IO1); also elsewhere on the board
CS: U4.17 (IO9); also elsewhere on the board
D_C: U4.10 (IO17); also elsewhere on the board
EN: C25.2, R26.1, SW2.1, SW2.2, U4.3 (EN)
GND: C20.1, C21.2, C22.2, C23.1, C24.1, C25.1, C26.1, C27.1, C35.1, C37.1, CN2.3, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D17.1, K1.2, K1.3, K2.2, K2.3, K3.2, K3.3, R12.2, R38.2, SW1.3, SW1.4, SW2.3, SW2.4, TF1.6 (VSS), TF1.10 (GND), TF1.11 (GND), TF1.12 (GND), TF1.13 (GND), U4.1 (GND), U4.40 (GND), U4.41 (GND); also elsewhere on the board
IO0: C20.2, R22.1, SW1.1, SW1.2, U4.27 (IO0)
KEY1: C26.2, D14.2, K1.1, R29.1, U4.32 (IO39)
KEY2: C27.2, D15.2, K2.1, R30.1, U4.33 (IO40)
KEY3: C35.2, D17.2, K3.1, R34.1, U4.34 (IO41)
unnamed: D10.2, R16.1, R23.1, TF1.5 (CLK)
unnamed: D9.2, R15.1, R21.1, TF1.3 (CMD)
unnamed: R27.2, U4.18 (IO10)
unnamed: R36.2, U4.13 (IO19)
unnamed: R37.2, U4.14 (IO20)
unnamed: R38.1, U4.16 (IO46)
RST: U4.11 (IO18); also elsewhere on the board
RX0: CN2.2, U4.36 (RXD0)
SCLK: R27.1; also elsewhere on the board
SDI: U4.19 (IO11); also elsewhere on the board
SD_CLK: R23.2, U4.6 (IO6)
SD_CMD: R21.2, U4.7 (IO7)
SD_D0: R24.2, U4.5 (IO5)
SD_D1: R25.2, U4.4 (IO4)
SD_D2: R19.2, U4.9 (IO16)
SD_D3: R20.2, U4.8 (IO15)
TX0: CN2.1, U4.37 (TXD0)
USB_DN: R36.1; also elsewhere on the board
USB_DP: R37.1; also elsewhere on the board
VDD3V3: C21.1, C22.1, C23.2, C24.2, D13.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R22.2, R26.2, R29.2, R30.2, R34.2, TF1.4 (VDD), U4.2 (3V3); also elsewhere on the board
VIN: R11.1; also elsewhere on the board

Notes on the sheet:
RST
Boot

Board: 2 copper layers, 66.5 x 83.9 mm, 102 parts (98 on the bottom side), 61 nets.

File HW/InkWordESP32_MB_V1.1/jlcpcb/production_files/BOM-InkWordESP32_MB_V1.1.csv:

Comment,Designator,Footprint,LCSC,Quantity
0R,"R7,R8",R0603,C100044,2
100nF ±10% 50V,"C1,C11,C2,C20,C22,C24,C25,C26,C27,C35,C37,C6,C7",C0603,C14663,13
100uH,L1,LQH3NPZ101MMEL,C703088,1
10kΩ,"R13,R14,R15,R16,R17,R18,R22,R26,R29,R30,R34,R38,R4,R6,R9",R0603,C25804,15
10uF 10V,"C10,C13,C21,C23,C3",C0603,C19702,5
10uF 50V,C19,C0805,C2932476,1
10Ω,"R19,R20,R21,R23,R24,R25,R36,R37",R0603,C109318,8
1MΩ ±1%,R12,R0603,C22935,1
1kΩ,R1,R0603,C22548,1
1uF,"C12,C14,C15,C16,C17,C4,C5,C8,C9",C0603,C15849,9
33Ω,R27,R0603,C23140,1
3MΩ ±1%,R11,R0603,C23156,1
3kΩ ±1%,R5,R0603,C4211,1
3Ω,R10,R0603,C22356394,1
4.7uF,C18,C0603,C69335,1
5.1kΩ ±1%,"R2,R3",R0603,C23186,2
600Ω@100MHz,FB1,L0603,C1002,1
AFC04-S24FCA-00,FPC1,AFC04-S24FCA-00,C883632,1
B5819WS,"D4,D5,D6",B5819WS,C7420331,3
BSMD0603L-100,"F1,F2",Fuse_0603_1608Metric,C2757929,2
ESP32-S3-WROOM-1_N16R8,U4,ESP32-S3-WROOM-1_N16R8,C2913202,1
GT-L5.2-W5.2-H015,"SW1,SW2",SW-SMD_4P-L5.2-W5.2-P3.70-LS6.4,C29780122,2
RCLAMP0521P-N,"D10,D11,D12,D13,D14,D15,D17,D7,D8,D9",RCLAMP0521P-N,C316043,10
RCLAMP0521T-ES,"D1,D2,D3",DFN1006-2L,C5180263,3
SI1308EDL-T1-GE3,Q1,SI1308EDL-T1-GE3,C469327,1
SS12D10G6-WJ,S1,SS12D10G6-WJ,C7431059,1
TF-CARD_H1_8,TF1,TF-CARD_H1_8,C7529389,1
TP4055,U2,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL,C28441,1
TS-1009B-05026,"K1,K2,K3",TS-1009B-05026,C455252,3
TYPE-C16PIN,USB1,TYPE-C16PIN,C393939,1
XB6366D,U1,XB6366D,C2760016,1
XC6220B331MR-G,U3,XC6220B331MR-G,C86534,1
ZX-XH2.54-2PWZ,CN1,CONN-TH_2P-P2.50_ZX-XH2.54-2PWZ,C7429641,1
ZX-XH2.54-3PZZ,,CONN-TH_3P-P2.54_2501S-3P,C7429633,0

## Code that names these connections

File SW/InkWordESP32_V1.1/InkWordESP32_V1.1.ino (part):

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// 墨水屏 SPI 引脚 (SE2417FS051 4.2寸三色屏，UC8176 主控，与 V1.0 硬件电路 100% 对齐)
const int PIN_CS = 9;
const int PIN_SCLK = 10;
const int PIN_SDI = 11;
const int PIN_RST = 18;
const int PIN_BUSY = 8;
const int PIN_D_C = 17;

// TF 卡 SDMMC 引脚 (4-bit 高速模式)
const int PIN_SD_CLK = 6;
const int PIN_SD_CMD = 7;
const int PIN_SD_DAT0 = 5;
const int PIN_SD_DAT1 = 4;
const int PIN_SD_DAT2 = 16;
const int PIN_SD_DAT3 = 15;

// 电源与按键引脚
const int PIN_BAT_ADC = 3;  // 电池电压检测 (1/4分压)
const int PIN_CHRG = 1;     // 充电指示 (正常高电平，充电低电平，充满由低变高)
const int PIN_KEY1 = 39;    // 键1: WiFi开关 / 单击进入 SmartConfig 配网
const int PIN_KEY2 = 40;    // 键2: 上一个单词 / 长按切顺序或随机模式 (带 NVS 记忆)
const int PIN_KEY3 = 41;    // 键3: 下一个单词 / 释义翻页 / 长按切词库 (带 NVS 记忆)

#include "LunarCalendar.h"
#include "WebManager.h"
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// 墨水屏驱动配置 (原生三色高对比度驱动: 纯正浓黑 + 鲜艳中国红)
// ----------------------------------------------------
#define EPD_CLASS GxEPD2_420c
GxEPD2_3C<EPD_CLASS, EPD_CLASS::HEIGHT> display(EPD_CLASS(PIN_CS, PIN_D_C, PIN_RST, -1));
#define COLOR_RED GxEPD_RED

SPIClass customSPI(HSPI); // 墨水屏专用SPI
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  const int SAMPLES = 16;
  uint32_t raw_vals[SAMPLES];
  for (int i = 0; i < SAMPLES; i++) {
    raw_vals[i] = analogReadMilliVolts(PIN_BAT_ADC);
    delayMicroseconds(200);
  }
  // 升序排序，剔除瞬态尖峰毛刺
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  initAndRestoreTime();

  // 1. 初始化 3 个按键及电量检测 (先调用 gpio_reset_pin 彻底解除 ESP32-S3 默认 JTAG 占用)
  rtc_gpio_hold_dis((gpio_num_t)PIN_CHRG); // 解除可能存在的深度休眠 RTC 锁存
  gpio_reset_pin((gpio_num_t)PIN_KEY1);
  gpio_reset_pin((gpio_num_t)PIN_KEY2);
  gpio_reset_pin((gpio_num_t)PIN_KEY3);
  gpio_reset_pin((gpio_num_t)PIN_CHRG);
  pinMode(PIN_KEY1, INPUT_PULLUP);
  pinMode(PIN_KEY2, INPUT_PULLUP);
  pinMode(PIN_KEY3, INPUT_PULLUP);
  pinMode(PIN_CHRG, INPUT_PULLUP);
  delay(20); // 硬件滤波电容上电缓冲
  Serial.printf(">>> 按键硬件电平初检: KEY1(GPIO %d)=%d, KEY2(GPIO %d)=%d, KEY3(GPIO %d)=%d (未按下正常为 1)\n",
                PIN_KEY1, digitalRead(PIN_KEY1), PIN_KEY2, digitalRead(PIN_KEY2), PIN_KEY3, digitalRead(PIN_KEY3));
  gpio_wakeup_enable((gpio_num_t)PIN_KEY1, GPIO_INTR_LOW_LEVEL);
  gpio_wakeup_enable((gpio_num_t)PIN_KEY2, GPIO_INTR_LOW_LEVEL);
  gpio_wakeup_enable((gpio_num_t)PIN_KEY3, GPIO_INTR_LOW_LEVEL);
  gpio_wakeup_enable((gpio_num_t)PIN_CHRG, GPIO_INTR_LOW_LEVEL); // 插入充电线自动唤醒
  esp_sleep_enable_gpio_wakeup();
  lastUserActivityTime = getUptimeMs();

  int rawChrg = digitalRead(PIN_CHRG);
  isCharging = (rawChrg == LOW);
  batteryPercent = calculateBatteryPercent();
  Serial.printf(">>> 硬件初检: PIN_CHRG (GPIO %d) 电平 = %d [%s], 电池电压 = %.2f V, 电量 = %.0f%%\n",
                PIN_CHRG, rawChrg, isCharging ? "正在充电 ⚡" : "未充电/已充满", getBatteryVoltage(), batteryPercent);

  // 2. 以 4-bit 模式初始化 SDMMC 卡
  SD_MMC.setPins(PIN_SD_CLK, PIN_SD_CMD, PIN_SD_DAT0, PIN_SD_DAT1, PIN_SD_DAT2, PIN_SD_DAT3);
  if (!SD_MMC.begin("/sdcard", false)) {
    Serial.println("TF卡 (SDMMC) 挂载失败！请检查硬件。");
  } else {
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  };

  // 4. 初始化 Eink 硬件 SPI 与 U8g2 字体引擎
  customSPI.begin(PIN_SCLK, -1, PIN_SDI, PIN_CS);
  display.epd2.selectSPI(customSPI, SPISettings(4000000, MSBFIRST, SPI_MODE0));
  display.init(115200, true, 2, false);
  display.setRotation(0);
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    if (savedList.empty()) {
      Serial.println("==================================================");
      Serial.println(">>> 新设备硬件初检：当前尚未配置 Wi-Fi 网络！");
      Serial.println(">>> 请按 KEY1 (GPIO 39) 开启热点与配网模式");
      Serial.println("==================================================");
    }
    toggleWifi(false);
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
    // 仅在真实测得有效极低电压 (<3.15V) 且未充电时，触发低电保护深度休眠
    float curBatV = getBatteryVoltage();
    if (curBatV >= 2.5f && curBatV < 3.15f && batteryPercent <= 5.0 && digitalRead(PIN_CHRG) == HIGH) {
      Serial.printf(">>> 电池电量极低 (%.2fV, %.0f%%)，执行最后一次屏幕刷新并进入深度休眠等待充电...\n", curBatV, batteryPercent);
      
      // 1. 同步执行完整页面渲染 (主屏幕保留完整的状态栏、时钟、日历、单词与名言，电池图标显示红框[!])
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      WiFi.mode(WIFI_OFF);
      esp_wifi_stop();
      
      // 4. 配置 PIN_CHRG (GPIO 1) RTC 域上拉与锁存，配置插入充电线(低电平)唤醒
      rtc_gpio_init((gpio_num_t)PIN_CHRG);
      rtc_gpio_set_direction((gpio_num_t)PIN_CHRG, RTC_GPIO_MODE_INPUT_ONLY);
      rtc_gpio_pullup_en((gpio_num_t)PIN_CHRG);
      rtc_gpio_pulldown_dis((gpio_num_t)PIN_CHRG);
      rtc_gpio_hold_en((gpio_num_t)PIN_CHRG); // 锁存上拉，杜绝深休眠期间引脚浮空误唤醒
      
      esp_sleep_enable_ext0_wakeup((gpio_num_t)PIN_CHRG, 0); // 插入充电线(GPIO1拉低)自动唤醒
      esp_deep_sleep_start();
    }

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  // ----------------------------------------------------
  // 充电状态实时硬件检测 (插上/拔出/充满自动感知并即时刷新)
  // ----------------------------------------------------
  static int lastChrgVal = digitalRead(PIN_CHRG); // 启动对齐当前真实电平，杜绝开机首轮误触发 Charger Plugged 刷屏
  int currChrgVal = digitalRead(PIN_CHRG);
  if (currChrgVal != lastChrgVal) {
    delay(40); // 硬件消抖
    currChrgVal = digitalRead(PIN_CHRG);
    if (currChrgVal != lastChrgVal) {
      lastChrgVal = currChrgVal;
      isCharging = (currChrgVal == LOW);
      batteryPercent = calculateBatteryPercent(); // 重新测量当前电量
      Serial.printf(">>> 充电状态跳变: %s (PIN_CHRG GPIO %d 电平=%d, 电量=%.0f%%, 电压=%.2f V)\n",
                    isCharging ? "充电中 [⚡]" : "未充电 / 已充满", PIN_CHRG, currChrgVal, batteryPercent, getBatteryVoltage());
      drawScreen(isCharging ? "Charger Plugged" : "Charger Unplugged/Full");
    }
  }
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  static bool keyPrevStates[3] = {HIGH, HIGH, HIGH};
  static bool keyInited = false;
  if (!keyInited) {
    keyPrevStates[0] = digitalRead(PIN_KEY1);
    keyPrevStates[1] = digitalRead(PIN_KEY2);
    keyPrevStates[2] = digitalRead(PIN_KEY3);
    keyInited = true;
  }
  int keyPins[3] = {PIN_KEY1, PIN_KEY2, PIN_KEY3};

  for (int i = 0; i < 3; i++) {
    bool currState = digitalRead(keyPins[i]);
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  }

  // 核心进阶节能：仅在非充电、无网络、无配网、屏幕空闲且无按键按下时进入 Light Sleep
  bool anyKeyPressed = (digitalRead(PIN_KEY1) == LOW || digitalRead(PIN_KEY2) == LOW || digitalRead(PIN_KEY3) == LOW);
  if (!isCharging && !wifiEnabled && !smartConfigMode && !apConfigMode && !screenUpdatePending && !isScreenBusy && !anyKeyPressed) {
    unsigned long interval = getWordSwitchInterval();
    unsigned long nowMs = getUptimeMs();
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  u8g2Fonts.print(cleanDictName);

  // 电池图标 (保留精美电池外框 + 内部纯白底显示，极低电量显示警告符号[!])
  isCharging = (digitalRead(PIN_CHRG) == LOW);
  bool isLow = (batteryPercent <= 20.0);
  bool isCritical = (batteryPercent <= 5.0 && !isCharging);
  uint16_t themeColor = (isLow || isCritical) ? COLOR_RED : GxEPD_BLACK;
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

Notices in the files:
README.md:
License: GPL v3
